## samples/nrf5340/net_spim_test/sample.yaml
```yaml
sample:
  description: Test if nRF53 net can use SPIM from app core
  name: nRF53 SPIM from app to net test
```
